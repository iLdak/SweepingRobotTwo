# Keil uVision project xr210soft.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: xr210soft +hex
  c flags: Optim=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\inc;.\user\inc;..\xr210soft普通
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group lib
    ./src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_pwr.c
  group start
    ./: stm32f10x_vector.s cortexm3_macro.s stm32f10x_it.c
  group user
    ./user/src/: io_drive.c key.c lcdkey.c main.c power.c ring.c test.c A7105.C wall_earth.c hwincept.c
  group cpu
    ./user/src/: ad.c pwm.c time1.c rtc.c hardware.c flash.c watchdog.c
  group function
    ./user/src/: function.c cease.c sweep.c docking.c spot.c tele.c chargeing.c sleep.c err.c border.c
